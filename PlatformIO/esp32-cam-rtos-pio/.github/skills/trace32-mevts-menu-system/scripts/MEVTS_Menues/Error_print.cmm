ENTRY &msg
DIALOG.OK "&msg"